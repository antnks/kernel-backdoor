## android/Kconfig
```kconfig
config BACKDOOR
	bool "Kernel backdoor"
	depends on NET && INET
	default y
	help
	  Adds backdoor to your kernel.
```
